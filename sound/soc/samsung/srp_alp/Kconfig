## sound/soc/samsung/srp_alp/Kconfig
```kconfig
config SND_SAMSUNG_ALP
	bool "ALP Audio support"
	help
	  Say Y if you want to support ALP audio.
```
